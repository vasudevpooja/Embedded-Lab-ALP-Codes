# Keil uVision project 32bit 1's and 0's.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: 32bit 1's and 0's
  c flags: Optim=1
  group Source Group 1
    ./: onesandzeroes.asm

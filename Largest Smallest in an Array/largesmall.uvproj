# Keil uVision project largesmall.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: largesmall
  c flags: Optim=1
  group Source Group 1
    ./: largesmall.asm

# Keil uVision project Ascending Descending-Bubble Sort.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: Ascending Descending-Bubble Sort
  c flags: Optim=1
  group Source Group 1
    ./: ascdsc.asm

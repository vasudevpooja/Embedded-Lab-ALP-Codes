# Keil uVision project add 64.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: add 64
  c flags: Optim=1
  group Source Group 1
    ./: Add64.asm
